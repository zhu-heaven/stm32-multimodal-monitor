# Keil uVision project LCD_ST7789.uvproj, settings and files
target LCD_ST7789 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD_ST7789 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\LCD;..\MPU6050;..\POSITION;..\MODEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c system_stm32f4xx.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx.h stm32f4xx_conf.h
    ./: project_config.h
  group LCD
    ../LCD/: lcd.c lcd.h lcd_font.h
  group MPU6050
    ../MPU6050/: mpu6050.c mpu6050.h
  group POSITION_ADC
    ../POSITION/: position.c position.h
  group MODEM_4G
    ../MODEM/: modem.c modem.h
  group PC_SERIAL
    ./: pc_serial.c pc_serial.h
  group WEATHER
    ./: weather.c weather.h
  group CORE
    ../CORE/: core_cm4_simd.h core_cm4.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_usart.c
    ../FWLIB/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_adc.h stm32f4xx_usart.h
  group FWLIB_REFERENCE
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash_ramfunc.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
    ../FWLIB/inc/: misc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash_ramfunc.h stm32f4xx_flash.h stm32f4xx_fmc.h stm32f4xx_fsmc.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_wwdg.h
  group KEY_K0
    ./: key.c key.h
  group BUZZER_K1
    ./: buzzer.c buzzer.h
  group TILT_ALGORITHM
    ./: tilt.c tilt.h
  group CHINESE_LCD_UI
    ./: display.c display.h
    ../LCD/: lcd_hz.h
  group CLOUD_BUZZER_CONTROL
    ./: cloud_command.c cloud_command.h
  group SOIL_FILTER
    ./: soil.c soil.h
  group RISK_SCORE_ALARM
    ./: risk.c risk.h
